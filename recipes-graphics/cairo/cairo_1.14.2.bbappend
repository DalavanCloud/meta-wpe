
# http://cgit.freedesktop.org/cairo/commit/?id=f52f0e2feb1ad0a4de23c475a8c020d41a1764a8
# (Also: https://github.com/Metrological/buildroot/blob/master/package/cairo/0007-transpose-the-matrix.patch )
SRC_URI += "file://Manually-transpose-the-matrix-in-_cairo_gl_shader_bi.patch"
