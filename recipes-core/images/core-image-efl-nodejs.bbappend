CORE_IMAGE_BASE_INSTALL += " \
	packagegroup-ml-middleware \
	packagegroup-ml-wpe \
	"
WPE_BACKEND = "nexus"
