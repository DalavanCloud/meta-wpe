
# It's not clear why mpg123 claims to depend on tslib, remove the dependency.
DEPENDS_remove = "tslib"
